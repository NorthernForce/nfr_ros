Commit message: ???

File: nfr_charged_up/config/swervy.urdf (robot description, URDF)
Before this commit: robot swervy, 2 links, 1 joints
Joints:
- joint realsense_joint: origin xyz=0.405 0 0.18 rpy=0 0 0 -> xyz=0 0 0.18 rpy=0 0 0
